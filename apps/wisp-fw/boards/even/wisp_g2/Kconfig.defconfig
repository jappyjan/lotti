## apps/wisp-fw/boards/even/wisp_g2/board.yml
```yaml
board:
  name: wisp_g2
  full_name: Even Realities G2 temple (Wisp native)
  socs:
    - name: apollo510b
```
